VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO logo_fabulous
  CLASS BLOCK ;
  FOREIGN logo_fabulous ;
  ORIGIN 0.000 0.000 ;
  SIZE 90.300 BY 90.300 ;
  OBS
      LAYER TopMetal1 ;
        RECT 0.0 0.0 90.300 90.300 ;
      LAYER Metal5 ;
        RECT 0.0 0.0 90.300 90.300 ;
  END
END logo_fabulous
END LIBRARY
