VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO logo_heichips
  CLASS BLOCK ;
  FOREIGN logo_heichips ;
  ORIGIN 0.000 0.000 ;
  SIZE 168.000 BY 75.600 ;
  OBS
      LAYER TopMetal1 ;
        RECT 0.0 0.0 168.000 75.600 ;
      LAYER Metal5 ;
        RECT 0.0 0.0 168.000 75.600 ;
  END
END logo_heichips
END LIBRARY
