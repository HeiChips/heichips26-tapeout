VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO logo_nct
  CLASS BLOCK ;
  FOREIGN logo_nct ;
  ORIGIN 0.000 0.000 ;
  SIZE 180.600 BY 90.300 ;
  OBS
      LAYER TopMetal1 ;
        RECT 0.0 0.0 180.600 90.300 ;
      LAYER Metal5 ;
        RECT 0.0 0.0 180.600 90.300 ;
  END
END logo_nct
END LIBRARY
